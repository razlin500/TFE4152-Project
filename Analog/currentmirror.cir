[aimspice]
[description]
16
Untitled circuit
[end]
